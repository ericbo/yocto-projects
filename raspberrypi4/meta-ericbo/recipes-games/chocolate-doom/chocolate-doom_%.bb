DESCRIPTION = "A Doom Clone based on SDL"
SECTION = "games"
DEPENDS = "libsdl2 libsdl2-mixer libsdl2-net pkgconfig"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

PV = "3.0.0"
PR = "r0"

SRC_URI = "https://github.com/chocolate-doom/chocolate-doom/archive/chocolate-doom-${PV}.tar.gz"
SRC_URI[md5sum] = "8bece4533e144ca01f13daa1b5912e95"
SRC_URI[sha256sum] = "73aea623930c7d18a7a778eea391e1ddfbe90ad1ac40a91b380afca4b0e1dab8"
